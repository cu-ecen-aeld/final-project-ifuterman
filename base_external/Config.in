## base_external/package/raspbery-air/Config.in
```kconfig
config BR2_PACKAGE_RASPBERY_AIR
	bool "raspbery-air"
	help
	  Includes project daemons and modules
```
